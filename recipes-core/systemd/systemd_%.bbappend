PACKAGECONFIG[acl] = "--enable-acl"
PACKAGECONFIG_remove = "networkd"
