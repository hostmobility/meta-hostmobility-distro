# Class to include some extra packages from Host Mobility layers

MACHINE_EXTRA_RDEPENDS_append = " \
    kernel-module-pic \
"
